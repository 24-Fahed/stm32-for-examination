# Keil uVision project stm32_test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Translater;..\Translater\Cmd_list;..\APP;..\Break_Service;..\CMSIS;..\FWLIB\inc;..\DEVICE\inc;..\APP\race_counter;..\APP\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c MYSYS.C stdio_user.c
  group DEVICE
    ../DEVICE/sec/: dev_ADC.c nixie.c UART_Send.c dev_button.c dev_key.c dev_led.c
    ../DEVICE/inc/: dev_beep.h
  group BREAK_SERVICE
    ../Break_Service/: break_service_UART.c break_service_Timer.c
  group APP
    ../APP/race_counter/: race_counter.c
    ../APP/timer/: timer.c
  group TRANSLATE
    ../Translater/Cmd_list/: cmd_ADC.c Cmd_list.c Cmd_list.h cmd_Send.h cmd_Race.h cmd_timer.h cmd_timer.c
    ../Translater/: translater.c
